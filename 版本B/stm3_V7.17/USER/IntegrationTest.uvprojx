# Keil uVision project IntegrationTest.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IntegrateTest +hex
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER SEGGER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\WDG;..\HARDWARE\TIMER;..\HARDWARE\OLED;..\HARDWARE\LCD;..\USMART;..\USER;..\MALLOC;..\HARDWARE\24CXX;..\HARDWARE\TOUCH;..\GUI;..\HARDWARE\FLASH;..\HARDWARE\SD;..\HARDWARE\SPI;..\TEXT;..\FATFS\exfuns;..\FATFS\src;..\PICTURE;..\HARDWARE\AUDIOSEL;..\HARDWARE\VS10XX;..\MP3;..\T9INPUT;..\ATKNCR;..\HARDWARE\DMA;..\HARDWARE\SRAMLCD;..\APP;..\HARDWARE\JOYPAD;..\NES;..\HARDWARE\RDA5820;..\HARDWARE\ADC;..\HARDWARE\DS18B20;..\3D;..\USB\CONFIG;..\USB\LIB;..\HARDWARE\BEEP;..\HARDWARE\ADXL345;..\HARDWARE\OV7670;..\HARDWARE\NRF24L01;..\HARDWARE\TPAD;..\HARDWARE\REMOTE;..\CORE;..\STM32F10x_FWLib\inc;..\HARDWARE\EXTI;..\IMG;..\HARDWARE\SSD1351;..\MENU;..\WORK;..\HARDWARE\LIS3DH;..\HARDWARE\WKUP;..\HARDWARE\ZKLED;..\RTT;..\HARDWARE\user_iaq2000;..\HARDWARE\user_sht20;..\HARDWARE\AT24Cxx;..\HARDWARE\user_PCF8563T;..\QRENCODE;..\MyPt;..\MyPt\pt-1.4;..\HARDWARE\TIMER
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: test.c system_stm32f10x.c includes.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/WKUP/: wkup.c
    ../HARDWARE/ZKLED/: zkled.c
    ../HARDWARE/LCD/: font.c font.h lcd.c lcd.h icon.c icon.h
    ../HARDWARE/user_iaq2000/: user_iaq2000.c user_iaq2000.h i2c0.c i2c0.h
    ../HARDWARE/user_sht20/: myiic2.c myiic2.h sht21.c sht21.h
    ../HARDWARE/AT24Cxx/: user_at24cxx.c user_at24cxx.h myiic.c myiic.h
    ../HARDWARE/user_PCF8563T/: myiic1.c myiic1.h user_pcf8563.c user_pcf8563.h
    ../HARDWARE/TIMER/: timer.c timer.h
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group QRENCODE
    ../QRENCODE/: bitstream.c mask.c mmask.c mqrspec.c QR_Encode.c qrencode.c qrinput.c qrspec.c rscode.c split.c
  group MENU
    ../MENU/: menu_show.c menu_show.h time_show.c time_show.h all_show.c all_show.h pm25_show.c pm25_show.h tvoc_show.c hcho_show.c tvoc_show.h co2_show.c co2_show.h charge_off_show.c charge_off_show.h
  group WORK
    ../WORK/: crc32.c clock_control.c flash_code.c user_watch_task.c user_watch_task.h user_key_task.c user_key_task.h all_sensor_task.c all_sensor_task.h user_si4432_control.c user_si4432_control.h user_data_save.c user_data_save.h calender.c user_wifi_cntrl.c user_wifi_cntrl.h user_nbiot_onenet_cntrl.c user_nbiot_onenet_cntrl.h user_nbiot_oneself_cntrl.c user_nbiot_oneself_cntrl.h user_nbiot_register_cntrl.c user_nbiot_register_cntrl.h print_sys_status.c
  group RTT
    ../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group MYPT
    ../MyPt/: sem.c sem.h systick.c systick.h thread.c thread.h typedef.h
software components: CMSIS:CORE 5.4.0
